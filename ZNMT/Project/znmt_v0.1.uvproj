# Keil uVision project znmt_v0.1.uvproj, settings and files
target znmt (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: znmt_v0.1 +hex
  c flags: Optimize=8
  c include: ..\App;..\Bsp
  group Startup
    ./: STARTUP.A51
  group App
    ../App/: main.c app.c
  group Bsp
    ../Bsp/: bsp_buz.c bsp_gpio.c bsp_pwm.c time.c usart.c bsp_moto.c bsp_key.c bsp_eeprom.c bsp_adc.c
